# IAR project nRF2401.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208R8 STM8S208R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\USER
  ICCSTM8.IccLang: 0
  ASTM8.AsmIncludePath: ..\FWlib\inc; ..\USER
  OBJCOPY.OOCOutputFile: nRF2401.hex
  ILINK.IlinkOutputFile: nRF2401.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWLib
    ../FWlib/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_spi.c stm8s_uart1.c
  group User
    ../USER/: main.c nRF24L01.c stm8s_it.c sysclock.c
    ../../29-nRF2401(发送 spi)/USER/: uart1.c
